# Keil uVision project Template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 工程模板 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\user;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\APP\LED;.\APP\SysTick;.\APP\beep;.\APP\key;.\APP\usart;.\APP\time;.\APP\PWM;.\APP\Track
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c stm32f10x_it.c public.c
  group cmsis
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c
  group APP
    ./APP/LED/: led.c
    ./APP/SysTick/: systick.c
    ./APP/beep/: beep.c
    ./APP/key/: key.c
    ./APP/usart/: usart.c
    ./APP/time/: time.c
    ./APP/PWM/: pwm.c
    ./APP/Track/: Track.c
  group README
    ./: README.txt
